# Keil uVision project STM32_F401RETx.uvprojx, settings and files
target F401 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32_F401RETx
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\include;..\..\config;..\..\boards
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group config
    ../../config/: config.h RTX_Conf_CM.c
  group examples
    ../../../: README.md
    ../../../examples/: example_01-blinkLED.c example_02-extLED.c example_03-userButton.c example_04-LCD.c example_05-KeyPad.c
  group templates
    ../../../templates/: main.template.c rtos.template.c
  group src
    ../../../src/: app.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.4.2
