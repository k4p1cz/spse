# Keil uVision project STM32_F407VGTx.uvprojx, settings and files
target F407 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32_F407VGTx
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\include;..\..\config;..\..\boards
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group config
    ../../config/: config.h RTX_Conf_CM.c
  group examples
    ../../../: README.md
    ../../../examples/: example_01-blinkLED.c example_02-extLED.c example_03-userButton.c example_04-LCD.c example_05-KeyPad.c example_06-blinkLED_TIMx.c example_07-blinkLED_TIMx-2.c
  group templates
    ../../../templates/: main.template.c rtos.template.c
  group src
    ../../../src/: app.c
    ./: app2.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.4.2
