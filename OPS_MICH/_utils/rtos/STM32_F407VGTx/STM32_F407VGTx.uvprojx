# Keil uVision project STM32_F407VGTx.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32_F407VGTx
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=2
  c include: ..\STM32\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group RTOS
    ./: RTX_Conf_CM.c
  group src
    ../: README.txt
    ../STM32/src/: STM32_00_HelloWorld_01-blinkLED.c STM32_00_HelloWorld_02-extLED.c STM32_00_HelloWorld_03-userButton.c STM32_00_HelloWorld_04-LCD.c STM32_00_HelloWorld_05-KeyPad.c STM32_00_HelloWorld_06-blinkLED_TIMx.c STM32_00_HelloWorld_07-blinkLED_TIMx-2.c
    ./: rtos_helloworld_05_keypad.c rtos_helloworld_00_rtx.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.4.2
