# Keil uVision project STM32_G071RBTx.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: STM32_G071RBTx
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\STM32\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ../: README.txt
    ../STM32/src/: STM32_00_HelloWorld_01-blinkLED.c STM32_00_HelloWorld_02-extLED.c STM32_00_HelloWorld_03-userButton.c STM32_00_HelloWorld_04-LCD.c STM32_00_HelloWorld_05-KeyPad.c STM32_00_HelloWorld_06-blinkLED_TIMx.c STM32_00_HelloWorld_07-blinkLED_TIMx-2.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
